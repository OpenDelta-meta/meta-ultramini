SRCDATE = "20170424"

require ultramini-dvb-modules.inc

SRC_URI[md5sum] = "90e18d1bb2ff14d8062dc75a21ac58d0"
SRC_URI[sha256sum] = "1768f70d39434afd41f6d2c368c4bc68a17ee04ad871baa480bf16919a31950c"

COMPATIBLE_MACHINE = "^(et7000mini)$"
